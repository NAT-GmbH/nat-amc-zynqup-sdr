options:
  parameters:
    author: tflorkowski
    generate_options: qt_gui
    id: phase_differences_sdr8
    output_language: python
    title: Phase Differences SDR8
  states: {}

blocks:
- name: buffer_size
  id: variable
  parameters:
    value: '0x40000'
  states: {}
- name: buffer_size_0
  id: variable
  parameters:
    value: '0x80000'
  states: {}
- name: period_samples
  id: variable
  parameters:
    value: '32768'
  states: {}
- name: pi
  id: variable
  parameters:
    value: ' 3.14159265359'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '7680000'
  states: {}
- name: average_len
  id: parameter
  parameters:
    label: Moving Average Length
    type: intx
    value: '1000000'
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0_0_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0_0_0_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0_0_0_0_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: average_len
    max_iter: '4000'
    scale: 1.0/float(average_len)
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: average_len
    max_iter: '4000'
    scale: 1.0/float(average_len)
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: average_len
    max_iter: '4000'
    scale: 1.0/float(average_len)
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_1
  id: blocks_moving_average_xx
  parameters:
    length: average_len
    max_iter: '4000'
    scale: 1.0/float(average_len)
    type: float
  states: {}
- name: blocks_moving_average_xx_0_1
  id: blocks_moving_average_xx
  parameters:
    length: average_len
    max_iter: average_len
    scale: 1.0/float(average_len)
    type: float
  states: {}
- name: blocks_moving_average_xx_0_1_0
  id: blocks_moving_average_xx
  parameters:
    length: average_len
    max_iter: average_len
    scale: 1.0/float(average_len)
    type: float
  states: {}
- name: blocks_moving_average_xx_0_1_0_0
  id: blocks_moving_average_xx
  parameters:
    length: average_len
    max_iter: average_len
    scale: 1.0/float(average_len)
    type: float
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0_0_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0_0_0_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0_0_0_0_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 180.0/pi
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 180.0/pi
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 180.0/pi
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 180.0/pi
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 180.0/pi
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 180.0/pi
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 180.0/pi
    type: float
  states: {}
- name: nat_amc_zynqup_sdr8_source_0
  id: nat_amc_zynqup_sdr8_source
  parameters:
    buffer_size: buffer_size
    gain1: '10'
    gain2: '30.0'
    gain3: '30.0'
    gain4: '30.0'
    gain5: '10.0'
    gain6: '10.0'
    gain7: '10.0'
    gain8: '10.0'
    gain_mode1: '''slow_attack'''
    gain_mode2: '''slow_attack'''
    gain_mode3: '''slow_attack'''
    gain_mode4: '''slow_attack'''
    hd2_tracking1: '0'
    hd2_tracking2: '0'
    hd2_tracking3: '0'
    hd2_tracking4: '0'
    hd2_tracking5: '0'
    hd2_tracking6: '0'
    hd2_tracking7: '0'
    hd2_tracking8: '0'
    lo_frequency1: '2400000000'
    lo_frequency2: '2400000000'
    lo_frequency3: '2400000000'
    lo_frequency4: '2400000000'
    quad_tracking1: '0'
    quad_tracking2: '0'
    quad_tracking3: '0'
    quad_tracking4: '0'
    quad_tracking5: '0'
    quad_tracking6: '0'
    quad_tracking7: '0'
    quad_tracking8: '0'
    rx1_en: '1'
    rx2_en: '1'
    rx3_en: '1'
    rx4_en: '1'
    rx5_en: '1'
    rx6_en: '1'
    rx7_en: '1'
    rx8_en: '1'
    rx_phase_corr_en1: '1'
    rx_phase_corr_en2: '1'
    rx_phase_corr_en3: '1'
    rx_phase_corr_en4: '1'
    rx_qec_en1: '1'
    rx_qec_en2: '1'
    rx_qec_en3: '1'
    rx_qec_en4: '1'
    samplerate: '7680000'
    uri: ip:192.168.1.160
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    entags: 'False'
    grid: 'True'
    label1: RX2
    label2: RX3
    label3: RX4
    label4: RX5
    label5: RX6
    label6: RX7
    label7: RX8
    name: '"Phase relative to RX1"'
    nconnections: '7'
    size: buffer_size*100
    srate: samp_rate/average_len
    type: float
    ylabel: Phase
    ymax: '+180'
    ymin: '-180'
  states: {}

connections:
- [blocks_complex_to_arg_0, '0', blocks_multiply_const_vxx_0_1_0, '0']
- [blocks_complex_to_arg_0_0, '0', blocks_multiply_const_vxx_0_0_0_0_0, '0']
- [blocks_complex_to_arg_0_0_0, '0', blocks_multiply_const_vxx_0_0_1_0, '0']
- [blocks_complex_to_arg_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [blocks_complex_to_arg_0_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_1, '0']
- [blocks_complex_to_arg_0_0_0_0_0_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_complex_to_arg_0_0_0_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_0_0_0, '0']
- [blocks_moving_average_xx_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_moving_average_xx_0_0_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_moving_average_xx_0_0_0_0, '0', qtgui_time_sink_x_1, '4']
- [blocks_moving_average_xx_0_0_1, '0', qtgui_time_sink_x_1, '3']
- [blocks_moving_average_xx_0_1, '0', qtgui_time_sink_x_1, '2']
- [blocks_moving_average_xx_0_1_0, '0', qtgui_time_sink_x_1, '5']
- [blocks_moving_average_xx_0_1_0_0, '0', qtgui_time_sink_x_1, '6']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_arg_0_0_0_0_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', blocks_complex_to_arg_0_0, '0']
- [blocks_multiply_conjugate_cc_0_0_0, '0', blocks_complex_to_arg_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0_0_0_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_multiply_conjugate_cc_0_0_0_0_0, '0', blocks_complex_to_arg_0_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0_0_0_0_0_0, '0', blocks_complex_to_arg_0_0_0_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0_0_0_0_0_0_0, '0', blocks_complex_to_arg_0_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0, '0', blocks_moving_average_xx_0_1, '0']
- [blocks_multiply_const_vxx_0_0_0_0_0, '0', blocks_moving_average_xx_0_1_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0_0_0, '0', blocks_moving_average_xx_0_1_0_0, '0']
- [blocks_multiply_const_vxx_0_0_1, '0', blocks_moving_average_xx_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_1_0, '0', blocks_moving_average_xx_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_multiply_const_vxx_0_1_0, '0', blocks_moving_average_xx_0_0_1, '0']
- [nat_amc_zynqup_sdr8_source_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [nat_amc_zynqup_sdr8_source_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [nat_amc_zynqup_sdr8_source_0, '0', blocks_multiply_conjugate_cc_0_0_0, '0']
- [nat_amc_zynqup_sdr8_source_0, '0', blocks_multiply_conjugate_cc_0_0_0_0, '0']
- [nat_amc_zynqup_sdr8_source_0, '0', blocks_multiply_conjugate_cc_0_0_0_0_0, '0']
- [nat_amc_zynqup_sdr8_source_0, '0', blocks_multiply_conjugate_cc_0_0_0_0_0_0, '0']
- [nat_amc_zynqup_sdr8_source_0, '0', blocks_multiply_conjugate_cc_0_0_0_0_0_0_0, '0']
- [nat_amc_zynqup_sdr8_source_0, '1', blocks_multiply_conjugate_cc_0_0_0_0_0_0, '1']
- [nat_amc_zynqup_sdr8_source_0, '2', blocks_multiply_conjugate_cc_0_0_0_0_0_0_0, '1']
- [nat_amc_zynqup_sdr8_source_0, '3', blocks_multiply_conjugate_cc_0_0_0_0_0, '1']
- [nat_amc_zynqup_sdr8_source_0, '4', blocks_multiply_conjugate_cc_0_0_0_0, '1']
- [nat_amc_zynqup_sdr8_source_0, '5', blocks_multiply_conjugate_cc_0_0_0, '1']
- [nat_amc_zynqup_sdr8_source_0, '6', blocks_multiply_conjugate_cc_0_0, '1']
- [nat_amc_zynqup_sdr8_source_0, '7', blocks_multiply_conjugate_cc_0, '1']

metadata:
  file_format: 1
