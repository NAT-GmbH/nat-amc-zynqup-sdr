options:
  parameters:
    author: Thomas Florkowski
    generate_options: qt_gui
    id: cosine_transmission_sdr4
    output_language: python
    title: Cosine Transmission SDR4
  states: {}

blocks:
- name: buffer_size
  id: variable
  parameters:
    value: '0x4000'
  states: {}
- name: period_samples
  id: variable
  parameters:
    value: '32768'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '7680000'
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: nat_amc_zynqup_sdr4_sink_0
  id: nat_amc_zynqup_sdr4_sink
  parameters:
    attenuation1: '10.0'
    attenuation2: '30.0'
    attenuation3: '30.0'
    attenuation4: '30.0'
    buffer_size: '32768'
    cyclic: 'False'
    leak_tracking1: '0'
    leak_tracking2: '0'
    leak_tracking3: '0'
    leak_tracking4: '0'
    lo_frequency1: '2400000000'
    lo_frequency2: '2400000000'
    quad_tracking1: '0'
    quad_tracking2: '0'
    quad_tracking3: '0'
    quad_tracking4: '0'
    samplerate: '7680000'
    tx1_en: '1'
    tx2_en: '0'
    tx3_en: '0'
    tx4_en: '0'
    tx_lol_en1: '1'
    tx_lol_en2: '1'
    tx_qec_en1: '1'
    tx_qec_en2: '1'
    uri: ip:192.168.1.160
  states: {}
- name: nat_amc_zynqup_sdr4_source_0
  id: nat_amc_zynqup_sdr4_source
  parameters:
    buffer_size: '32768'
    gain1: '10.0'
    gain2: '10.0'
    gain3: '10.0'
    gain4: '10.0'
    gain_mode1: '''slow_attack'''
    gain_mode2: '''manual'''
    hd2_tracking1: '0'
    hd2_tracking2: '0'
    hd2_tracking3: '0'
    hd2_tracking4: '0'
    lo_frequency1: '2400000000'
    lo_frequency2: '2400000000'
    quad_tracking1: '0'
    quad_tracking2: '0'
    quad_tracking3: '0'
    quad_tracking4: '0'
    rx1_en: '1'
    rx2_en: '0'
    rx3_en: '0'
    rx4_en: '0'
    rx_phase_corr_en1: '1'
    rx_phase_corr_en2: '1'
    rx_qec_en1: '1'
    rx_qec_en2: '1'
    samplerate: '7680000'
    uri: ip:192.168.1.160
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Send Signal"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '2400000000'
    fftsize: '1024'
    name: '"Received Signal"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_sig_source_x_0_0, '0', nat_amc_zynqup_sdr4_sink_0, '0']
- [analog_sig_source_x_0_0, '0', qtgui_sink_x_0, '0']
- [nat_amc_zynqup_sdr4_source_0, '0', qtgui_sink_x_1, '0']

metadata:
  file_format: 1
